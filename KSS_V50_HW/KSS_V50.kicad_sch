File: KSS_V50_HW/KSS_V50.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: post assembly commit
Parts:
- added H1, H2: MountingHole, ap_built:24929, symbol Mechanical:MountingHole
